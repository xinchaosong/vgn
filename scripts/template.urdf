Commit message: Update the code to generate the urdfs for acronym

File: scripts/template.urdf (robot description, URDF)
Before this commit: robot obj_name, 1 links, 0 joints
Links:
- link base_link: geometry collision mesh filename=obj_path; visual mesh filename=obj_path
